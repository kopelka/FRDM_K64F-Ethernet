# Keil uVision project FRDM_K64F-Ethernet.uvprojx, settings and files
target FRDM_K64F-Ethernet (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: FRDM_K64F-Ethernet
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=2
  c define: TARGET_KSDK2_MCUS DEVICE_RTC=1 DEVICE_SLEEP=1 ARM_MATH_CM4 TARGET_KPSDK_CODE TARGET_MCU_K64F __ASSERT_MSG TARGET_RELEASE DEVICE_CRC=1 MBED_BUILD_TIMESTAMP=1541585072.76 DEVICE_LPTICKER=1 DEVICE_PORTINOUT=1 COMPONENT_SD=1 DEVICE_PWMOUT=1 TARGET_FF_ARDUINO TARGET_RTOS_M4_M7 TARGET_Freescale_EMAC DEVICE_SPISLAVE=1 DEVICE_PORTOUT=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGOUT=1 TARGET_LIKE_MBED DEVICE_SERIAL_FC=1 TARGET_FRDM FEATURE_STORAGE=1 TARGET_LIKE_CORTEX_M4 TARGET_CORTEX_M DEVICE_SERIAL=1 MBED_ROM_SIZE=0x100000 TARGET_KPSDK_MCUS TARGET_Freescale DEVICE_USTICKER=1 DEVICE_I2C=1 __CORTEX_M4 TARGET_CORTEX TARGET_MCUXpresso_MCUS TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 DEVICE_ANALOGIN=1 TOOLCHAIN_ARM_STD __CMSIS_RTOS DEVICE_EMAC=1 DEVICE_SERIAL_ASYNCH=1 DEVICE_TRNG=1 DEVICE_SPI=1 __MBED__=1 TARGET_K64F CPU_MK64FN1M0VMD12 DEVICE_STORAGE=1 MBED_ROM_START=0x0 DEVICE_PORTIN=1 TARGET_M4 __FPU_PRESENT=1 DEVICE_I2CSLAVE=1 FSL_RTOS_MBED DEVICE_SPI_ASYNCH=1 __MBED_CMSIS_RTOS_CM
  c misc: --no_rtti --split_sections -c --cpu=Cortex-M4.fp --no_depend_system_headers --md --gnu --apcs=interwork --preinclude=mbed_config.h
  c include: .;EthernetInterface;EthernetInterface/Socket;EthernetInterface/lwip;EthernetInterface/lwip-eth/arch/TARGET_K64F;EthernetInterface/lwip-sys;EthernetInterface/lwip-sys/arch;EthernetInterface/lwip/include;EthernetInterface/lwip/include/ipv4;EthernetInterface/lwip/include/ipv4/lwip;EthernetInterface/lwip/include/lwip;EthernetInterface/lwip/include/netif;EthernetInterface/lwip/netif;EthernetInterface/lwip/netif/ppp;mbed;mbed-rtos;mbed-rtos/rtos;mbed-rtos/rtx;mbed/TARGET_K64F;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common/phyksz8081;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock/src;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/enet;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/interrupt;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/pit;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/adc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/can;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dmamux;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dspi;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/edma;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/enet;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/flextimer;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/gpio;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/i2c;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/mcg;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/osc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pit;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pmc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/port;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/rtc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sai;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sdhc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sim;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/smc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/uart;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/wdog;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/utilities;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/TARGET_FRDM;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device/MK64F12
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\mbed\TARGET_K64F\TOOLCHAIN_ARM_STD\MK64F.sct
  link misc: --show_full_path
  group EthernetInterface
    EthernetInterface/lwip/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcp_impl.h tcpip.h timers.h udp.h
    EthernetInterface/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    EthernetInterface/lwip/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    EthernetInterface/lwip/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h ppp_oe.c pppdebug.h randm.c randm.h vj.c vj.h
    EthernetInterface/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    EthernetInterface/lwip/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
    EthernetInterface/lwip-sys/arch/: cc.h checksum.c memcpy.c perf.h sys_arch.c sys_arch.h
    EthernetInterface/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    EthernetInterface/Socket/: Endpoint.cpp Endpoint.h Socket.cpp Socket.h TCPSocketConnection.cpp TCPSocketConnection.h TCPSocketServer.cpp TCPSocketServer.h UDPSocket.cpp UDPSocket.h
    EthernetInterface/: eth_arch.h EthernetInterface.cpp EthernetInterface.h
    EthernetInterface/lwip/netif/: etharp.c ethernetif.c slipif.c
    EthernetInterface/lwip/include/netif/: etharp.h ppp_oe.h slipif.h
    EthernetInterface/lwip-eth/arch/TARGET_K64F/: fsl_enet_driver.c hardware_init_MK64F12.c k64f_emac.c k64f_emac_config.h lwipopts_conf.h
    EthernetInterface/lwip/: lwipopts.h
  group FRDM_K64F-Ethernet
    ./: main.cpp mbed_config.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
    mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar mbed_overrides.o retarget.o startup_MK64F12.o sys.o system_MK64F12.o
    mbed/TARGET_K64F/: cmsis.h cmsis_nvic.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h MK64F12.h system_MK64F12.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: device.h PeripheralNames.h PinNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/adc/: fsl_adc_features.h fsl_adc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock/: fsl_clock_configs.h fsl_clock_manager.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock/src/: fsl_clock_manager_private.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device/: fsl_device_registers.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dmamux/: fsl_dmamux_features.h fsl_dmamux_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dspi/: fsl_dspi_features.h fsl_dspi_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/edma/: fsl_edma_features.h fsl_edma_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/enet/: fsl_enet_driver.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/enet/: fsl_enet_features.h fsl_enet_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/can/: fsl_flexcan_features.h fsl_flexcan_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/flextimer/: fsl_ftm_features.h fsl_ftm_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/gpio/: fsl_gpio_features.h fsl_gpio_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/i2c/: fsl_i2c_features.h fsl_i2c_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/interrupt/: fsl_interrupt_features.h fsl_interrupt_manager.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/mcg/: fsl_mcg_features.h fsl_mcg_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/utilities/: fsl_os_abstraction.h fsl_os_abstraction_mbed.h sw_timer.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/osc/: fsl_osc_features.h fsl_osc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common/phyksz8081/: fsl_phy_driver.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/pit/: fsl_pit_driver.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pit/: fsl_pit_features.h fsl_pit_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pmc/: fsl_pmc_features.h fsl_pmc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/port/: fsl_port_features.h fsl_port_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/rtc/: fsl_rtc_features.h fsl_rtc_hal.h fsl_rtc_hal_access_control.h fsl_rtc_hal_monotonic.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sai/: fsl_sai_features.h fsl_sai_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sdhc/: fsl_sdhc_features.h fsl_sdhc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sim/: fsl_sim_features.h fsl_sim_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/smc/: fsl_smc_features.h fsl_smc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/uart/: fsl_uart_features.h fsl_uart_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/wdog/: fsl_wdog_features.h fsl_wdog_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/: gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device/MK64F12/: MK64F12.h MK64F12_adc.h MK64F12_aips.h MK64F12_axbs.h MK64F12_can.h MK64F12_cau.h MK64F12_cmp.h MK64F12_cmt.h MK64F12_crc.h MK64F12_dac.h MK64F12_dma.h MK64F12_dmamux.h MK64F12_enet.h MK64F12_ewm.h MK64F12_fb.h MK64F12_fmc.h MK64F12_ftfe.h MK64F12_ftm.h MK64F12_gpio.h MK64F12_i2c.h MK64F12_i2s.h MK64F12_llwu.h MK64F12_lptmr.h MK64F12_mcg.h MK64F12_mcm.h MK64F12_mpu.h MK64F12_nv.h MK64F12_osc.h MK64F12_pdb.h MK64F12_pit.h MK64F12_pmc.h MK64F12_port.h MK64F12_rcm.h MK64F12_rfsys.h MK64F12_rfvbat.h MK64F12_rng.h MK64F12_rtc.h MK64F12_sdhc.h MK64F12_sim.h MK64F12_smc.h MK64F12_spi.h MK64F12_uart.h MK64F12_usb.h MK64F12_usbdcd.h MK64F12_vref.h MK64F12_wdog.h regs.h system_MK64F12.h
  group mbed-rtos
    mbed-rtos/rtx/: cmsis_os.h HAL_CM.c os_tcb.h rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Mutex.c rt_Mutex.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf.h RTX_Conf_CM.c
    mbed-rtos/rtx/TARGET_M4/TOOLCHAIN_ARM/: HAL_CM4.c SVC_Table.s
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
